RDEPENDS:${PN}:append:onekvm-nanokvm = " onekvm-kernel-module-npu"
